options:
  parameters:
    generate_options: qt_gui
    id: top_block
    output_language: python
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: blks2_packet_decoder_0
  id: blks2_packet_decoder
  parameters:
    access_code: ''
    threshold: '-1'
    type: byte
  states: {}
- name: blks2_packet_decoder_0_0
  id: blks2_packet_decoder
  parameters:
    access_code: ''
    threshold: '-1'
    type: byte
  states: {}
- name: blks2_packet_encoder_0
  id: blks2_packet_encoder
  parameters:
    access_code: ''
    bits_per_symbol: '1'
    pad_for_usrp: 'True'
    payload_length: '1'
    preamble: ''
    samples_per_symbol: '1'
    type: byte
  states: {}
- name: blks2_packet_encoder_0_0
  id: blks2_packet_encoder
  parameters:
    access_code: ''
    bits_per_symbol: '1'
    pad_for_usrp: 'True'
    payload_length: '1'
    preamble: ''
    samples_per_symbol: '1'
    type: byte
  states: {}
- name: blocks_multiply_const_vxx_1
  id: blocks_multiply_const_vxx
  parameters:
    const: '500'
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_1_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '500'
    type: complex
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: byte
  states: {}
- name: blocks_throttle_0_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: byte
  states: {}
- name: channels_channel_model_0
  id: channels_channel_model
  parameters:
    epsilon: '1.0'
    freq_offset: '0.0'
    noise_voltage: '50'
    seed: '0'
    taps: 1.0 + 1.0j
  states: {}
- name: channels_channel_model_0_0
  id: channels_channel_model
  parameters:
    epsilon: '1.0'
    freq_offset: '0.0'
    noise_voltage: '50'
    seed: '0'
    taps: 1.0 + 1.0j
  states: {}
- name: digital_gmsk_demod_0
  id: digital_gmsk_demod
  parameters:
    freq_error: '0.0'
    gain_mu: '0.175'
    mu: '0.5'
    omega_relative_limit: '0.005'
    samples_per_symbol: '2'
  states: {}
- name: digital_gmsk_demod_0_0
  id: digital_gmsk_demod
  parameters:
    freq_error: '0.0'
    gain_mu: '0.175'
    mu: '0.5'
    omega_relative_limit: '0.005'
    samples_per_symbol: '2'
  states: {}
- name: digital_gmsk_mod_0
  id: digital_gmsk_mod
  parameters:
    bt: '0.35'
    samples_per_symbol: '2'
  states: {}
- name: digital_gmsk_mod_0_0
  id: digital_gmsk_mod
  parameters:
    bt: '0.35'
    samples_per_symbol: '2'
  states: {}
- name: network_tcp_sink_0
  id: network_tcp_sink
  parameters:
    mode: '2'
    port: '1239'
    type: byte
  states: {}
- name: network_tcp_sink_0_0
  id: network_tcp_sink
  parameters:
    mode: '2'
    port: '1238'
    type: byte
  states: {}
- name: network_tcp_source_0
  id: network_tcp_source
  parameters:
    addr: 127.0.0.1
    port: '5001'
    server: 'True'
    type: byte
  states: {}
- name: network_tcp_source_0_0
  id: network_tcp_source
  parameters:
    addr: 127.0.0.1
    port: '5002'
    server: 'True'
    type: byte
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    autoscale: 'True'
    bw: samp_rate
    fc: '0'
    fftsize: '4096'
    grid: 'True'
    showports: 'True'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    autoscale: 'True'
    bw: samp_rate
    fc: '0'
    fftsize: '4096'
    grid: 'True'
    showports: 'True'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}

connections:
- [blks2_packet_decoder_0, '0', network_tcp_sink_0, '0']
- [blks2_packet_decoder_0_0, '0', network_tcp_sink_0_0, '0']
- [blks2_packet_encoder_0, '0', digital_gmsk_mod_0, '0']
- [blks2_packet_encoder_0_0, '0', digital_gmsk_mod_0_0, '0']
- [blocks_multiply_const_vxx_1, '0', channels_channel_model_0, '0']
- [blocks_multiply_const_vxx_1_0, '0', channels_channel_model_0_0, '0']
- [blocks_throttle_0, '0', blks2_packet_encoder_0, '0']
- [blocks_throttle_0_0, '0', blks2_packet_encoder_0_0, '0']
- [channels_channel_model_0, '0', digital_gmsk_demod_0, '0']
- [channels_channel_model_0, '0', qtgui_freq_sink_x_0, '0']
- [channels_channel_model_0_0, '0', digital_gmsk_demod_0_0, '0']
- [channels_channel_model_0_0, '0', qtgui_freq_sink_x_0_0, '0']
- [digital_gmsk_demod_0, '0', blks2_packet_decoder_0, '0']
- [digital_gmsk_demod_0_0, '0', blks2_packet_decoder_0_0, '0']
- [digital_gmsk_mod_0, '0', blocks_multiply_const_vxx_1, '0']
- [digital_gmsk_mod_0_0, '0', blocks_multiply_const_vxx_1_0, '0']
- [network_tcp_source_0, '0', blocks_throttle_0, '0']
- [network_tcp_source_0_0, '0', blocks_throttle_0_0, '0']

metadata:
  file_format: 1
  grc_version: 3.9.7.0
