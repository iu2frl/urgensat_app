options:
  parameters:
    generate_options: no_gui
    id: top_block
    output_language: python
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: blocks_multiply_const_vxx_1
  id: blocks_multiply_const_vxx
  parameters:
    const: '500'
    type: complex
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: byte
  states: {}
- name: channels_channel_model_0
  id: channels_channel_model
  parameters:
    epsilon: '1.0'
    freq_offset: '0.0'
    noise_voltage: '50'
    seed: '0'
    taps: 1.0 + 1.0j
  states: {}
- name: digital_gmsk_demod_0
  id: digital_gmsk_demod
  parameters:
    freq_error: '0.0'
    gain_mu: '0.175'
    mu: '0.5'
    omega_relative_limit: '0.005'
    samples_per_symbol: '2'
  states: {}
- name: digital_gmsk_mod_0
  id: digital_gmsk_mod
  parameters:
    bt: '0.35'
    samples_per_symbol: '2'
  states: {}
- name: grnet_tcp_sink_0
  id: grnet_tcp_sink
  parameters:
    addr: 127.0.0.1
    mode: '1'
    port: '1238'
    type: byte
    vlen: '1'
  states: {}
- name: grnet_tcp_source_0
  id: grnet_tcp_source
  parameters:
    addr: 127.0.0.1
    port: '5001'
    server: 'True'
    type: byte
    vlen: '1'
  states: {}

connections:
- [blocks_multiply_const_vxx_1, '0', channels_channel_model_0, '0']
- [blocks_throttle_0, '0', digital_gmsk_mod_0, '0']
- [channels_channel_model_0, '0', digital_gmsk_demod_0, '0']
- [digital_gmsk_demod_0, '0', grnet_tcp_sink_0, '0']
- [digital_gmsk_mod_0, '0', blocks_multiply_const_vxx_1, '0']
- [grnet_tcp_source_0, '0', blocks_throttle_0, '0']

metadata:
  file_format: 1
  grc_version: 3.9.7.0
